# IAR project Project.ewp, settings and files
configuration STM3210E debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_STM3210E_EVAL
  ICCARM.CCIncludePath2: ..\; ..\..\Utilities\STM32_EVAL; ..\..\Utilities\STM32_EVAL\STM3210E_EVAL; ..\..\Libraries\CMSIS\Core\CM3; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\Project\lcd; ..\..\Project\sdcard; ..\..\Project\fatfs; ..\..\Project\speaker; ..\..\Project\player; ..\..\Project\rencoder; ..\..\Project\button; ..\..\Project\ledm; ..\..\Project\clock; ..\..\Project\bluetooth; ..\..\Project\motor; ..\..\Project\temp
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: STM3210E-EVAL.out
  ILINK.IlinkIcfFile: STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Bluetooth_Driver
    ../bluetooth/: bluetooth.c
  group Button_Driver
    ../button/: button.c
  group Clock_Driver
    ../clock/: clock.c
  group CMSIS
    ../../Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
  group EWARMv5
    ../../Libraries/CMSIS/Core/CM3/startup/iar/: startup_stm32f10x_hd.s
  group FatFs
    ../fatfs/: diskio.c ff.c
  group LCD_Driver
    ../lcd/: lcd.c
  group LEDM_Driver
    ../ledm/: ledm.c
  group Motor_Driver
    ../motor/: motor.c
  group Player
    ../player/: waveplayer.c
  group REncoder_Driver
    ../rencoder/: rencoder.c
  group SDcard_Driver
    ../sdcard/: sdcard.c
  group Speaker_Driver
    ../speaker/: speaker.c
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group STM32_EVAL
    ../../Utilities/STM32_EVAL/: stm32_eval.c
  group Temp_Driver
    ../temp/: OneWire.c temp.c
  group User
    ../: main.c main.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
